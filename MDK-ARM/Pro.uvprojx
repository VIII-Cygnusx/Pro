# Keil uVision project Pro.uvprojx, settings and files
target Pro (6210000::V6.21::ARMCLANG)
  device: STM32U575RITx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.2.1
  cpu: IRAM(0x20000000-0x200BFFFF) IROM(0x08000000-0x81FFFFF)  CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: Pro +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U575xx
  c include: ../Core/Inc;../TouchGFX/App;../TouchGFX/target/generated;../TouchGFX/target;../Drivers/STM32U5xx_HAL_Driver/Inc;../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../Drivers/CMSIS/Include;./Hardware/FT6336;./Hardware/ILI9341;./Hardware/W25Q128;./Hardware/GPS;./Hardware/MPU6050/DMP;../MY_Math;../PIPE_LINE;./Hardware/OV7725_interface;./Hardware/MAX30102;./Hardware/AP3216C;./Hardware/SHT20;../middlewares/st/touchgfx/framework/include;../touchgfx/generated/fonts/include;../touchgfx/generated/gui_generated/include;../touchgfx/generated/images/include;../touchgfx/generated/texts/include;../touchgfx/generated/videos/include;../touchgfx/gui/include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  scatter file: Pro\Pro.sct
  group Application/MDK-ARM
    ./: startup_stm32u575xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c crc.c dma2d.c gpdma.c i2c.c memorymap.c octospi.c spi.c tim.c usart.c stm32u5xx_it.c stm32u5xx_hal_msp.c stm32u5xx_hal_timebase_tim.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_dma2d.c stm32u5xx_hal_ospi.c stm32u5xx_ll_dlyb.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group gui
    ../touchgfx/gui/src/containers/: arona.cpp calender.cpp clock_inner.cpp gnss.cpp system.cpp test.cpp
    ../touchgfx/gui/src/cam_setting_screen/: cam_settingpresenter.cpp cam_settingview.cpp
    ../touchgfx/gui/src/cam_screen/: campresenter.cpp camview.cpp
    ../touchgfx/gui/src/compass_screen/: compasspresenter.cpp compassview.cpp
    ../touchgfx/gui/src/env_screen/: envpresenter.cpp envview.cpp
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/game_screen/: gamepresenter.cpp gameview.cpp
    ../touchgfx/gui/src/health_screen/: healthpresenter.cpp healthview.cpp
    ../touchgfx/gui/src/imu_screen/: imupresenter.cpp imuview.cpp
    ../touchgfx/gui/src/locat_screen/: locatpresenter.cpp locatview.cpp
    ../touchgfx/gui/src/main_screen/: mainpresenter.cpp mainview.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/sport_setting_screen/: sport_settingpresenter.cpp sport_settingview.cpp
    ../touchgfx/gui/src/sport_screen/: sportpresenter.cpp sportview.cpp
    ../touchgfx/gui/src/system_screen/: systempresenter.cpp systemview.cpp
    ../touchgfx/gui/src/timer_screen/: timerpresenter.cpp timerview.cpp
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_led_20_4bpp_0.cpp font_led_40_4bpp_0.cpp font_stxihei_ttf_20_4bpp_0.cpp font_stxihei_ttf_20_4bpp_10.cpp font_stxihei_ttf_20_4bpp_12.cpp font_stxihei_ttf_20_4bpp_9.cpp font_verdana_10_4bpp_0.cpp font_verdana_20_4bpp_0.cpp font_verdana_40_4bpp_0.cpp font_verdana_80_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_led_20_4bpp.cpp kerning_led_40_4bpp.cpp kerning_stxihei_ttf_20_4bpp.cpp kerning_verdana_10_4bpp.cpp kerning_verdana_20_4bpp.cpp kerning_verdana_40_4bpp.cpp kerning_verdana_80_4bpp.cpp table_led_20_4bpp.cpp table_led_40_4bpp.cpp table_stxihei_ttf_20_4bpp.cpp table_verdana_10_4bpp.cpp table_verdana_20_4bpp.cpp table_verdana_40_4bpp.cpp table_verdana_80_4bpp.cpp unmappeddatafont.cpp vectorfontrendererbuffers.cpp
    ../touchgfx/generated/gui_generated/src/containers/: aronabase.cpp calenderbase.cpp clock_innerbase.cpp gnssbase.cpp systembase.cpp testbase.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp image_ball.cpp image_big_down.cpp image_big_pointer.cpp image_big_quit.cpp image_big_right.cpp image_big_ring.cpp image_big_up.cpp image_big_void.cpp image_black_ring.cpp image_cam.cpp image_clock.cpp image_compass.cpp image_cycle.cpp image_down.cpp image_duiwai.cpp image_empty.cpp image_env.cpp image_game.cpp image_health.cpp image_imu.cpp image_joy1.cpp image_joy2.cpp image_joy3.cpp image_left.cpp image_map_locat.cpp image_meau.cpp image_meau_big.cpp image_paused.cpp image_s1.cpp image_satt.cpp image_setting.cpp image_standby.cpp image_start.cpp image_start_new.cpp image_stop.cpp image_sys.cpp image_timer.cpp image_up.cpp svgdatabase.cpp
    ../touchgfx/generated/gui_generated/src/cam_setting_screen/: cam_settingviewbase.cpp
    ../touchgfx/generated/gui_generated/src/cam_screen/: camviewbase.cpp
    ../touchgfx/generated/gui_generated/src/compass_screen/: compassviewbase.cpp
    ../touchgfx/generated/gui_generated/src/env_screen/: envviewbase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/gui_generated/src/game_screen/: gameviewbase.cpp
    ../touchgfx/generated/gui_generated/src/health_screen/: healthviewbase.cpp
    ../touchgfx/generated/images/src/__generated/: image_alternate_theme_images_containers_small_wide_dark.cpp
    ../touchgfx/generated/gui_generated/src/imu_screen/: imuviewbase.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/locat_screen/: locatviewbase.cpp
    ../touchgfx/generated/gui_generated/src/main_screen/: mainviewbase.cpp
    ../touchgfx/generated/gui_generated/src/sport_setting_screen/: sport_settingviewbase.cpp
    ../touchgfx/generated/gui_generated/src/sport_screen/: sportviewbase.cpp
    ../touchgfx/generated/gui_generated/src/system_screen/: systemviewbase.cpp
    ../touchgfx/generated/gui_generated/src/timer_screen/: timerviewbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m33/Keil6.x/: touchgfx_core_wchar16.lib
  group Hardware
    ./Hardware/FT6336/: ft6336_api.c ft6336_interface.c touch_info.c
    ./Hardware/ILI9341/: ili9341_api.c ili9341_interface.c screem_info.c
    ./Hardware/W25Q128/: bsp_ospi_w25q128.c
    ./Hardware/GPS/: GPS_api.c GPS_info.c GPS_interface.c
    ./Hardware/MPU6050/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c user_MPU6050.c
    ./Hardware/OV7725_interface/: image_info.c ov7725.api.c ov7725_interface.c SCCB.c
    ./Hardware/MAX30102/: algorithm_max30102.c max30102.c user_max30102.c
    ./Hardware/AP3216C/: bsp_ap3216c.c
    ./Hardware/SHT20/: bsp_sht20.c
  group MyMath
    ../MY_Math/: myMath.c
  group PIPE_line
    ../PIPE_LINE/: task_PIPE.c
software components: CMSIS:CORE 4.3.0
